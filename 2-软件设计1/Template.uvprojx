# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103R6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_LD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\exti;.\APP\time;.\APP\lcd1602;.\APP\dac0832;.\App_demo;.\APP\pcf8591;.\APP\iic;.\APP\ds18b20;.\APP\key;.\APP\step_motor;.\APP\dht11;.\APP\led;.\APP\pid;.\APP\pwm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_adc.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/lcd1602/: lcd1602.c
    ./APP/key/: key.c
    ./APP/beep/: beep.c
    ./APP/ds18b20/: ds18b20.c
    ./APP/iic/: iic.c
    ./APP/pcf8591/: pcf8591.c
    ./APP/pid/: pid.c
    ./APP/pwm/: pwm.c
    ./APP/bridge/: bridge.c
  group Public
    ./Public/: system.c SysTick.c
  group App_demo
    ./App_demo/: app_demo.c
